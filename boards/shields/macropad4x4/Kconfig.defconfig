## boards/shields/macropad4x4/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD4X4

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "macropad4x4"

endif
```
